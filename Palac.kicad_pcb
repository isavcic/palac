# Repository isavcic/palac

File README.md:

# Palac

Ortholinear 5x6+1 split keyboard. **Work in progress.**

## Overview

Palac came to be as an offshoot of Sofle. The current idea behind it is to create a straightforward split keyboard: no rotary encoders, no backlight, and to explore no stagger in the pinky column: with the pinky positioned slightly below the center of the home row key, in case of five rows one could reach the top and the bottom row with same ease.

## KiCad design Palac.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: D; Diode_SOD123
J2: 4PIN; MJ-4PP-9
R1, R2: R; R_1206_DoubleSided
RSW1: SW_RST; TACT_SWITCH_TVBP06
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW99: SW_PUSH; CherryMX_Hotswap
TH3, TH4, TH5, TH6, TH7: HOLE; HOLE_M2_TH
U1: ProMicro; ArduinoProMicro-ZigZag-DoubleSided

Connections:
GND: J2.2, RSW1.1, SW99.1, U1.3 (GND), U1.4 (GND), U1.23 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
RESET: RSW1.2, U1.22 (RST)
SCL: J2.4, R2.2, U1.6 (SCL(PD0))
SDA: J2.3, R1.2, U1.5 (SDA(PD1))
SW99: SW99.2, U1.19 (A2(PF5))
VCC: J2.1, R1.1, R2.1, U1.21 (VCC)
col0: SW6.1, SW12.1, SW18.1, SW24.1, SW30.1, U1.18 (A1(PF6))
col1: SW5.1, SW11.1, SW17.1, SW23.1, SW29.1, U1.17 (A0(PF7))
col2: SW4.1, SW10.1, SW16.1, SW22.1, SW28.1, U1.16 (D15(PB1))
col3: SW3.1, SW9.1, SW15.1, SW21.1, SW27.1, U1.15 (D14(PB3))
col4: SW2.1, SW8.1, SW14.1, SW20.1, SW26.1, U1.14 (D16(PB2))
col5: SW1.1, SW7.1, SW13.1, SW19.1, SW25.1, U1.13 (D10(PB6))
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.8 (D5(PC6))
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.9 (D6(PD7))
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.10 (D7(PE6))
row3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.11 (D8(PB4))
row4: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.12 (D9(PB5))

Board: 2 copper layers, 139.6 x 113.5 mm, 71 parts (2 on the bottom side), 47 nets.

## Commit log

2023-02-17 More info
2023-02-20 Updated layout
2023-02-20 Modified description
2023-02-20 Tidy
